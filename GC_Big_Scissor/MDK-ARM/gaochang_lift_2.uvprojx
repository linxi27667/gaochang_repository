# Keil uVision project gaochang_lift_2.uvprojx, settings and files
target gaochang_lift_2 (5060960::V5.06 update 7 (build 960)::.\ARMCC_v5)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: gaochang_lift_2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../APP/Inc;../APP/Src;../BSP/Inc;../BSP/Src;../RTT_easylog/easylogger/inc;../RTT_easylog/easylogger/plugins;../RTT_easylog/easylogger/port;../RTT_easylog/easylogger/src;../RTT_easylog/RTT;../Middlewares/FIFO;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Driver;../Driver/Inc;../Driver/Src
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group APP
    ../APP/Src/: app_spi.c app_maintenance.c lift_iot.c app_tas_dtu.c app_w25qxx.c app_product.c app_rise_counter.c app_rise_queue.c app_io_map.c app_op_log.c lift_core.c lift_lock.c lift_large_scissor.c
    ../APP/Inc/: app_spi.h app_maintenance.h lift_iot.h app_tas_dtu.h app_w25qxx.h app_rs485.h app_product.h app_rise_counter.h app_rise_queue.h app_io_map.h app_op_log.h lift_core.h lift_lock.h
  group BSP
    ../BSP/Src/: bsp_spi.c bsp_w25qxx.c bsp_uart.c
    ../BSP/Inc/: bsp_spi.h bsp_w25qxx.h bsp_uart.h
  group Middlewares/FIFO
    ../Middlewares/FIFO/: fifo.c fifo.h
  group EasyLog
    ../RTT_easylog/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../RTT_easylog/easylogger/port/: elog_port.c
    ../RTT_easylog/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Driver
    ../Driver/Src/: dri_lift.c dri_tas_dtu.c
    ../Driver/Inc/: dri_lift.h dri_tas_dtu.h
software components: CMSIS:CORE 5.6.0
