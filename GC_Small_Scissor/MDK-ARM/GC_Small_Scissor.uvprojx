# Keil uVision project GC_Small_Scissor.uvprojx, settings and files
target GC_Small_Scissor (5060960::V5.06 update 7 (build 960)::.\ARMCC_v5)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GC_Small_Scissor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../APP/Inc;../BSP/Inc;../Driver/Inc;../Driver/Src;../Middlewares/FIFO;../RTT_easylog/RTT;../RTT_easylog/easylogger/inc;../RTT_easylog/easylogger/port;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/APP
    ../APP/Src/: app_product.c app_io_map.c app_spi.c app_w25qxx.c app_op_log.c app_lift_core.c app_lift_small_scissor.c app_tas_dtu.c lift_iot.c
    ../APP/Inc/: lift_iot.h app_tas_dtu.h
  group BSP
    ../BSP/Src/: bsp_spi.c bsp_w25qxx.c bsp_uart.c
  group Driver
    ../Driver/Src/: dri_lift.c dri_key.c dri_motor.c dri_safety.c dri_tas_dtu.c
    ../Driver/Inc/: dri_lift.h dri_key.h dri_motor.h dri_safety.h dri_tas_dtu.h
  group Middlewares/FIFO
    ../Middlewares/FIFO/: fifo.c fifo.h
  group RTT_easylog
    ../RTT_easylog/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../RTT_easylog/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../RTT_easylog/easylogger/port/: elog_port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
