<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RTC6_IOT_LIFT.ewp</path>
  </project>
  <batchBuild />
</workspace>
