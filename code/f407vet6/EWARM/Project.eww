<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Ball And Plant System.ewp</path>
  </project>
  <batchBuild />
</workspace>
